# Keil uVision project AESslave_modified_test_copy.uvprojx, settings and files
target AESslave_modified_test_copy (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.pdsc
  cpu: CPUTYPE("Cortex-M0")
  output: AESslave_modified_test_copy
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_WIZNET -DARM_MATH_CM0 -D__ASSERT_MSG -DTARGET_WIZwiki_W7500 --no_rtti -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE --split_sections -DTARGET_LIKE_CORTEX_M0 -D__CORTEX_M0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M0 -DMBED_BUILD_TIMESTAMP=1506507813.03 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -DTARGET_WIZWIKI_W7500 --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_W7500x -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -D__MBED_CMSIS_RTOS_CM
  c include: .; UDAES; AES; CRC; mbed/.; mbed/TARGET_WIZwiki_W7500; mbed/TARGET_WIZwiki_W7500/TARGET_WIZNET; mbed/TARGET_WIZwiki_W7500/TARGET_WIZNET/TARGET_W7500x; mbed/TARGET_WIZwiki_W7500/TARGET_WIZNET/TARGET_W7500x/TARGET_WIZwiki_W7500; mbed/TARGET_WIZwiki_W7500/TARGET_WIZNET/TARGET_W7500x/W7500x_Peripheral_Library; mbed/TARGET_WIZwiki_W7500/TARGET_WIZNET/TARGET_W7500x/device; mbed/TARGET_WIZwiki_W7500/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_WIZwiki_W7500/TOOLCHAIN_ARM_STD/W7500.sct
  group AES
    AES/: AES.cpp AES.h
  group AESslave_modified_test_copy
    ./: main.cpp mbed_config.h
  group CRC
    CRC/: crc.cpp crc.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_WIZwiki_W7500/TOOLCHAIN_ARM_STD/: analogin_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o i2c_api.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o startup_W7500x.o sys.o system_W7500x.o us_ticker.o W7500x_adc.o W7500x_crg.o W7500x_dualtimer.o W7500x_exti.o W7500x_gpio.o W7500x_i2c.o W7500x_pwm.o W7500x_uart.o
    mbed/TARGET_WIZwiki_W7500/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_WIZwiki_W7500/TARGET_WIZNET/TARGET_W7500x/device/: cmsis.h cmsis_nvic.h system_W7500x.h W7500x.h
    mbed/TARGET_WIZwiki_W7500/TARGET_WIZNET/TARGET_W7500x/TARGET_WIZwiki_W7500/: device.h PinNames.h
    mbed/TARGET_WIZwiki_W7500/TARGET_WIZNET/TARGET_W7500x/: gpio_object.h objects.h PeripheralNames.h PeripheralPins.h PortNames.h
    mbed/: mbed.h
    mbed/TARGET_WIZwiki_W7500/TARGET_WIZNET/TARGET_W7500x/W7500x_Peripheral_Library/: W7500x_adc.h W7500x_conf.h W7500x_crg.h W7500x_dualtimer.h W7500x_exti.h W7500x_gpio.h W7500x_i2c.h W7500x_pwm.h W7500x_uart.h
  group UDAES
    UDAES/: udaes.cpp udaes.h
